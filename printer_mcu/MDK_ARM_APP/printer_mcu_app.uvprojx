# Keil uVision project printer_mcu_app.uvprojx, settings and files
target printer_mcu_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: printer_mcu_app +hex
  AfterMake: python ..\binHEBING\binMerge.py
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,APP_USE_IAP
  c include: ..\include;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\USER;..\USER\delay;..\USER\led;..\BSP\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: main.c crc16.c stm32f10x_it.c TIM.C usart.c belt.c key_and_light.c roll_paper.c printer.c air_cylinder.c communication.c baffle.c flash.c
    ../USER/delay/: delay.c
    ../USER/led/: led.c
    ../BSP/EXTI/: exti.c
  group LIBRARIES
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group remark
    ../: 调试备注.txt
software components: CMSIS:CORE 5.1.2
